Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2016-06-15T11:30:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160525_1230(x64) - Exporter 16.0.1144.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 15 11:30:11 2016 * Host: gebruiker-PC * Database: C:\Users\GEBRUI~1\AppData\Local\Temp\{5164144C-6969-413C-BD34-5243A3FBB8B1}\ifc * Database version: 5507 * Database creation date: Wed Jun 15 11:30:10 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 15 11:30:11 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 15 11:30:11 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowTerminal: D21R1-LEDN10SX2, Dummy:D21R1-LEDN10SX2:202586
In: Level 1
Type - Material: BE_G Glas lamp, BE_G Reflector, BE Armatuur
Type - Constraints - Default Elevation: 1219.2 mm; WT_H Behuizing: Standaard; WT_H Diameter: 190 mm; WT_H Offset lichtbron: 116.653 mm; WT_H Symbool straal: 100 mm
Type - Dimensions - BE_G Diameter: 200 mm; BE_G Hoogte: 212 mm
Type - Electrical - BE_E Arbeidsfactor: 1; BE_E Belastingsklasse: Verlichting; BE_E Schijnbaar vermogen: 14.8 W; BE_E Spanning: 230 V
Type - Graphics - WT_V Symbool plafond: led - rond; WT_V Symbool wand: geen
Type - Identity Data - BE_I Bestelcode: D21R1/LEDN10SX2; Manufacturer: ETAP; Model: D2R1 led; Type Name: D21R1-LEDN10SX2; WT_I BaseKeynote: 63.1
Type - Materials and Finishes - BE_G Materiaal/Kleur: BE Armatuur; WT_V Materiaal_reflector: BE_G Reflector
Type - Model Properties - WT_I Armatuurrendement: 0.9; WT_I IP klasse: -; WT_I Kleur: grijs; WT_I Maatschets catalogus: -; WT_I Maximale temperatuur: -; WT_I Montage: Opbouw; WT_I Optiek: downlight - breedstralend; WT_I UGR: <=22; WT_I Voorschakelapparaat: S; WT_I Vorm: rond
Type - Other - Category: Lighting Fixtures; Family Name: Dummy; WT_c1 Omschrijving: c1_Elektrische voeding
Type - Photometrics - WT_H Lichtbron: BE_E_GEO Armatuur_ETAP D2 - lichtbron - LED: D21R1_LEDN10X1_S; WT_I Aantal lampen: 1; WT_I Afschermhoek: 65 deg; WT_I Lamptype: LED; WT_I Luminantie: 0; WT_I Vermogen lamp: 14.8 W
Pset_ManufacturerTypeInformation - Manufacturer: ETAP
Pset_DistributionFlowElementCommon - Reference: D21R1-LEDN10SX2
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.0980135 m2; Volume: 0.00665986 m3
Electrical - Circuiting - Electrical Data: c1_Elektrische voeding 230 V/1-15 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 45
Other - Family: Dummy: D21R1-LEDN10SX2; Family and Type: Dummy: D21R1-LEDN10SX2; Schedule Level: Level: Level 1; Type: Dummy: D21R1-LEDN10SX2; Type Id: Dummy: D21R1-LEDN10SX2
Phasing - Phase Created: 469492
